# Keil uVision project sample2_1.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: MDR1986BE92 Milandr
  pack: Keil.MDR1986BExx.1.4
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: cantest +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\CAN TEST;.\RTE;.\RTE\Device;.\RTE\Device\MDR1986BE92;.\rtos;.\rtos\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: main.c MDR32F9Qx_it.c init.c button.c uart_io.c ParseCommands.c ParseCommands.h
  group RTOS
    ./rtos/: croutine.c event_groups.c heap_2.c list.c port.c queue.c tasks.c timers.c
    ./rtos/include/: FreeRTOSConfig.h
  group MLT
    ./MLT/: mlt_lcd.c
  group RegEx
    ./: trex.c trex.h
software components: CMSIS:CORE 5.0.1, Device:Startup_MDR1986BE9x 1.3.1, Drivers:ADC 1.3.1, Drivers:BKP 1.3.1, Drivers:CAN 1.3.1, Drivers:COMP 1.3.1, Drivers:DAC 1.3.1, Drivers:DMA 1.3.1, Drivers:EBC 1.3.1, Drivers:EEMPROM 1.3.1, Drivers:I2C 1.3.1, Drivers:IWDG 1.3.1, Drivers:LIB 1.3.1, Drivers:PORT 1.3.1, Drivers:POWER 1.3.1, Drivers:RST_CLK 1.3.1, Drivers:SSP 1.3.1, Drivers:TIMER 1.3.1, Drivers:UART 1.3.1
